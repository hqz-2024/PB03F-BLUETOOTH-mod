# Keil uVision project bleUart_AT.uvprojx, settings and files
target ble_uart_at (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: bleuart
  AfterMake: fromelf.exe --bin -o  ./bin  ./Objects/bleuart.axf
  AfterMake: fromelf.exe .\Objects\bleuart.axf --i32combined --output .\bin\bleuart.hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP PHY_6222 BLEUART_AT MTU_SIZE=247 USE_FS OSAL_SNV_UINT16_ID CFG_QFN32 CFG_SLEEP_MODE=PWR_MODE_NO_SLEEP  HOST_CONFIG=4 HCI_TL_NONE=1 ENABLE_LOG_ROM_=0 PHY_MCU_TYPE=MCU_BUMBEE_M0 MAX_NUM_LL_CONN=1 GATT_MAX_NUM_CONN = MAX_NUM_LL_CONN+1
  c misc: -DADV_NCONN_CFG=0x01   -DADV_CONN_CFG=0x02   -DSCAN_CFG=0x04    -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02   -DPERIPHERAL_CFG=0x04   -DCENTRAL_CFG=0x08   -DHOST_CONFIG=0x4
  c include: ..\..\..\components\ble\include;..\..\..\components\inc;..\..\..\components\ble\controller\include;..\..\..\components\ble\hci;..\..\..\components\osal\include;..\..\..\components\common;..\..\..\components\ble\host;..\..\..\components\profiles\Roles;..\..\..\components\driver\uart;..\..\..\components\profiles\DevInfo;..\..\..\components\profiles\SimpleProfile;..\..\..\components\driver\common;..\..\..\components\driver\log;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\uart;..\..\..\components\driver\clock;..\..\..\components\driver\gpio;..\..\..\components\driver\adc;..\..\..\components\driver\kscan;..\..\..\components\driver\flash;..\..\..\lib;..\..\..\components\driver\spi;..\..\..\components\driver\i2c;..\..\..\components\driver\watchdog;..\..\..\components\driver\timer;..\..\..\components\driver\spiflash;..\..\..\components\ethermind\mesh\export\include;..\..\..\components\ethermind\osal\src\phyos;..\..\..\components\ethermind\platforms\meshlibs;..\..\..\components\libraries\fs;..\..\..\example\ble_peripheral\bleUart_AT\Source;..\..\..\components\arch\cm0;..\..\..\components\ble\controller;..\..\..\misc;..\..\..\components\driver\dma
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x1fff8000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\misc\bb_rom_sym_m0.txt --keep=jump_table_base  --keep=global_config
  group arch
    ./Source/: main.c bleuart_at_cmd.c
  group profile
    ../../../components/profiles/DevInfo/: devinfoservice.c
    ../../../components/profiles/Roles/: gap.c gapbondmgr.c gapgattserver.c
    ../../../components/profiles/Keys/: simplekeys.c
    ../../../components/profiles/GATT/: gattservapp.c
    ./Source/: peripheral.c
  group jump
    ../../../misc/: jump_table.c
  group app
    ./Source/: bleuart.c bleuart_Main.c bleuart_service.c OSAL_bleuart.c bleuart_protocol.c bleuart_at_dma.c
  group rf
    ../../../lib/: rf.lib ble_host.lib
  group driver
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/flash/: flash.c
    ./Source/: led.c
    ../../../components/driver/dma/: dma.c
    ../../../components/driver/watchdog/: watchdog.c
  group osal
    ../../../components/osal/snv/: osal_snv.c
  group cli
    ./Source/: cliface.c
  group fs
    ../../../components/libraries/fs/: fs.c
  group fs2
    ../../../components/libraries/fs2/: fs.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1
