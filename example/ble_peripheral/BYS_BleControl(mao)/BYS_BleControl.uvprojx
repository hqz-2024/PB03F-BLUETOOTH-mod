# Keil uVision project BYS_BleControl.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: BYS_BleControl +hex
  AfterMake: fromelf.exe --bin -o  ./bin  ./Objects/BYS_BleControl.axf
  AfterMake: fromelf.exe .\Objects\BYS_BleControl.axf --i32combined --output .\bin\BYS_BleControl.hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OSALMEM_METRICS=0 DBG_ROM_MAIN=0 MTU_SIZE=247 DEBUG_INFO=3 _BUILD_FOR_DTM_=0 ENABLE_LOG_ROM_=0 HOST_CONFIG=0xC HCI_TL_NONE=1 OSAL_CBTIMER_NUM_TASKS=1 CFG_CP PHY_MCU_TYPE=MCU_BUMBEE_M0 CFG_SLEEP_MODE=PWR_MODE_NO_SLEEP MULTI_DEBUG MAX_NUM_LL_CONN=6 GATT_MAX_NUM_CONN = MAX_NUM_LL_CONN+1
  c misc: -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08 -DHOST_CONFIG=0xc
  c include: ..\..\..\components\inc;..\..\..\components\ble\controller;..\..\..\components\osal\include;..\..\..\components\common;..\..\..\components\ble\include;..\..\..\components\ble\hci;..\..\..\components\ble\host;..\..\..\components\profiles\HID;..\..\..\components\Profiles\Roles;.\source;..\..\..\components\libraries\crc16;..\..\..\components\libraries\fs;..\..\..\components\driver\clock;..\..\..\components\arch\cm0;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\uart;..\..\..\components\driver\gpio;..\..\..\components\driver\timer;..\..\..\misc;..\..\..\components\driver\log;..\..\..\components\libraries\cliface;..\..\..\components\driver\key;..\..\..\components\driver\pwm;..\..\..\components\driver\flash;..\..\..\components\driver\watchdog
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x1fff8000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group app
    ./Source/: OSAL_Main.c CFLOS.c CFLOS.h APP_SharedFunction.c APP_SharedFunction.h BYS_BLEControl_Application.c BYS_BLEControl_Application.h BYS_BLEControl_Dev.c BYS_BLEControl_Dev.h
  group arch
    ./: main.c
  group driver
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/timer/: timer.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/key/: key.c
    ../../../components/driver/pwm/: pwm.c
    ../../../components/osal/snv/: osal_snv.c
    ../../../components/driver/flash/: flash.c
    ../../../components/driver/watchdog/: watchdog.c
  group profile
    ../../../components/profiles/Roles/: central.c gap.c gapbondmgr.c gapgattserver.c peripheral.c
    ../../../components/profiles/GATT/: gattservapp.c
  group jump
    ../../../misc/: jump_table.c
  group lib
    ../../../lib/: rf.lib ble_host.lib
  group fs
    ../../../components/libraries/fs/: fs.c
  group fs2
    ../../../components/libraries/fs2/: fs.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
